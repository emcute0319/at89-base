# IAR project AT89_Base.ewp, settings and files
configuration Debug (8051, debug)
  General.DerivativeDescriptionFile: $TOOLKIT_DIR$\config\devices\
  General.RTConfigPath: xxx.h
  ICC8051.OCCDataMemoryModel: 1
  ICC8051.OCCCodeMemoryModel: 1
  ICC8051.CCOptLevel: 1
  ICC8051.CCOptStrategy: 0
  XLINK.XclFile: lnk0t.xcl
configuration Release (8051)
  as the first configuration, except:
  ICC8051.CCDefines: NDEBUG
  ICC8051.CCIncludePath2: ..\..\app; ..\..\cfg; ..\..\drv; ..\..\inc; ..\..\os
  ICC8051.CCStdIncludePath: $TOOLKIT_DIR$\INC\; $TOOLKIT_DIR$\INC\CLIB\
  ICC8051.CCOptLevel: 3
  postbuild: after_build.bat
  XLINK.XclFile: $TOOLKIT_DIR$\config\lnk51ew.xcl
  group app
    ../../app/: app.h thread_idle.c thread_idle.h
  group cfg
    ../../cfg/: cfg_hw_def.h cfg_protothread.h
  group drv
    ../../drv/: compiler_defs.h drv.c drv.h drv_cpu.c drv_cpu.h drv_i2cm.c drv_i2cm.h drv_i2cs.c drv_i2cs.h drv_int.h drv_io.c drv_io.h drv_spi.c drv_spi.h drv_timer.h drv_uart.c drv_uart.h drv_vector.c drv_vector.h drv_watchdog.h reg_def_at89.h
  group os
    ../../os/: lc-switch.h lc.h protothread.c protothread.h pt-sem.h pt.h
  group startup
    ../../startup/: main.c
