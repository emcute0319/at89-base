# Keil uVision project AT89_Base.uvproj, settings and files
target AT89_Base (MCS-51)
  device: AT89C2051 Atmel
  cpu: IRAM(0-0x7F) IROM(0-0x7FF) CLOCK(24000000)
  output: AT89_Base +hex
  AfterMake: after_build.bat $P.. @L
  c flags: Optimize=9 SizeSpeed=1
  c include: ..\app;..\cfg;..\drv;..\inc;..\os
  asm include: ..\os;..\apl;..\cfg;..\drv;..\inc;..\plf
  link misc: REMOVEUNUSED
  group startup
    ../startup/: main.c
  group drv
    ../drv/: startup.S drv.c drv_cpu.c drv_vector.c drv_io.c drv_uart.c drv_spi.c drv_i2cm.c drv_i2cs.c drv_led.c drv_led_sim.c drv_led_max7219.c drv_temp.c drv_temp_ds18b20.c drv_swi.c
  group os
    ../os/: protothread.c
  group app
    ../app/: thread_idle.c
