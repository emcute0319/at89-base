# IAR project AVR_Base.ewp, settings and files
configuration Debug (AVR, debug)
  General.LCHeapSize: 0x10
  General.SCCStackSize: 0x20
  General.SCRStackSize: 16
  General.LCTinyHeapSize: 0x10
  General.LCNearHeapSize: 0x20
  General.LCFarHeapSize: 0x1000
  General.LCHugeHeapSize: 0x1000
  ICCAVR.IExtraOptions: --string_literals_in_flash
  ICCAVR.newCCIncludePaths: ..\app; ..\cfg; ..\drv; ..\inc; ..\os; ..\build\tmp\
  ICCAVR.CCStdIncludePaths: $TOOLKIT_DIR$\INC\; $TOOLKIT_DIR$\INC\CLIB\
  prebuild: before_build.bat .. $PROJ_FNAME$
  XLINK.XclFile: $TOOLKIT_DIR$\src\template\cfgm16.xcl
configuration Release (AVR)
  as the first configuration, except:
  ICCAVR.CCDefines: NDEBUG
  ICCAVR.newCCIncludePaths: ..\app; ..\cfg; ..\drv; ..\inc; ..\os; ..\build\tmp
  postbuild: after_build.bat .. $PROJ_FNAME$
  XLINK.XExtraOptions: -y(CODE); -Ointel-extended,(DATA)=$EXE_DIR$\$PROJ_FNAME$_data.hex; -Ointel-extended,(XDATA)=$EXE_DIR$\$PROJ_FNAME$_eeprom.hex
  group app
    ../app/: thread_app.c thread_idle.c
  group drv
    ../drv/: drv.c drv_cpu.c drv_i2cm.c drv_i2cs.c drv_io.c drv_led.c drv_led_max7219.c drv_led_sim.c drv_spi.c drv_temp.c drv_temp_ds18b20.c drv_uart.c drv_vector.c
  group os
    ../os/: protothread.c
  group startup
    ../startup/: main.c
